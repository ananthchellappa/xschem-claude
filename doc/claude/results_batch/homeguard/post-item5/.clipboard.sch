v {xschem version=3.4.8RC file_version=1.3}
G { 0 0 }
#XSCHEM_CLIPBOARD_VIEW=schematic
