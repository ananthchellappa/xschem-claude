v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -60 0 -30 0 {lab=#net1}
N -50 -20 -30 -20 {lab=#net2}
C {SANDBOX/solar_ctl} 120 -10 0 0 {name=x1}
