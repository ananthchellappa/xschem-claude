** sch_path: sky130A/xschem_libs/sky130_tests/test_comparator/schematic/test_comparator.sch
* Copyright 2021 Stefan Frederik Schippers
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
* https://www.apache.org/licenses/LICENSE-2.0
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
**.subckt test_comparator CAL PLUS MINUS EN VSS VCC SAOUT
*.ipin CAL
*.ipin PLUS
*.ipin MINUS
*.ipin EN
*.ipin VSS
*.ipin VCC
*.opin SAOUT
C38 VSS 0 2p m=1
C3 SAOUTF 0 15f m=1
C30 SN 0 2f m=1
C1 OUTDIFF 0 15f m=1
vndiff net1 VSSI 0
.save i(vndiff)
v3 net4 VSSI 0
.save i(v3)
v4 net3 VSSI 0
.save i(v4)
v6 net2 VSSI 0
.save i(v6)
C13 SAOUT 0 15f m=1
v1 net5 VSSI 0
.save i(v1)
v5 net6 VSSI 0
.save i(v5)
C7 GN1 0 4f m=1
x4 CALBB CALB VCC VSS not W_N=1 L_N=0.15 W_P=2 L_P=0.15 m=1
x5 CALB CAL VCC VSS not W_N=1 L_N=0.15 W_P=2 L_P=0.15 m=1
XM4 SP VSS net7 VCC sky130_fd_pr__pfet_01v8 L=2 W=1.2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 GP2 GP2 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 GP1 GP1 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 SAOUTF OUTDIFF VCC VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XM9 SAOUT SAOUTF VCC VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XM11 SAOUT EN VCC VCC sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 VSSI EN VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=8 nf=1 ad='int((1 + 1)/2) * 8 / 1 * 0.29' as='int((1 + 2)/2) * 8 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (8 / 1 + 0.29)' nrd='0.29 / 8 ' nrs='0.29 / 8 '
+ sa=0 sb=0 sd=0 mult=2 m=2
XM15 SAOUT SAOUTF net5 VSS sky130_fd_pr__nfet_01v8_lvt L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM10 SAOUTF OUTDIFF net4 VSS sky130_fd_pr__nfet_01v8_lvt L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM17 SN VCC net1 VSS sky130_fd_pr__nfet_01v8_lvt L=7 W=0.7 nf=1 ad='int((1 + 1)/2) * 0.7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.7 / 1 + 0.29)'
+ nrd='0.29 / 0.7 ' nrs='0.29 / 0.7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM18 GN2 GN2 VSSI VSS sky130_fd_pr__nfet_01v8_lvt L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM19 GN1 GN1 VSSI VSS sky130_fd_pr__nfet_01v8_lvt L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM20 GN2 MINUS SP VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=6 nf=1 ad='int((1 + 1)/2) * 6 / 1 * 0.29' as='int((1 + 2)/2) * 6 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (6 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6 / 1 + 0.29)' nrd='0.29 / 6 ' nrs='0.29 / 6 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM21 GN1 PLUS SP VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=6 nf=1 ad='int((1 + 1)/2) * 6 / 1 * 0.29' as='int((1 + 2)/2) * 6 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (6 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6 / 1 + 0.29)' nrd='0.29 / 6 ' nrs='0.29 / 6 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM23 GP2 MINUS SN VSS sky130_fd_pr__nfet_01v8 L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM16 GP1 PLUS SN VSS sky130_fd_pr__nfet_01v8 L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 OUTDIFF ZERO0 CALB CALBB VCC VSS passgate W_N=0.42 L_N=0.15 W_P=0.7 L_P=0.15 m=1
x2 SAOUTF ZERO1 CALB CALBB VCC VSS passgate W_N=0.42 L_N=0.15 W_P=0.7 L_P=0.15 m=1
x3 SAOUT ZERO2 CALB CALBB VCC VSS passgate W_N=0.42 L_N=0.15 W_P=0.7 L_P=0.15 m=1
C8 GN2 0 4f m=1
C9 GP1 0 4f m=1
C10 GP2 0 4f m=1
XM22 GP1 GN2 VSSI VSS sky130_fd_pr__nfet_01v8_lvt L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM25 OUTDIFF GN1 net8 VSS sky130_fd_pr__nfet_01v8_lvt L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM26 OUTDIFF GP1 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XC5 ZERO2 VSS sky130_fd_pr__cap_mim_m3_1 W=4 L=5 MF=1 m=1
XC2 ZERO1 VSS sky130_fd_pr__cap_mim_m3_1 W=4 L=5 MF=1 m=1
XC4 ZERO0 VSS sky130_fd_pr__cap_mim_m3_1 W=4 L=5 MF=1 m=1
XM3 SAOUTF ZERO1 net3 VSS sky130_fd_pr__nfet_01v8_lvt L=3 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM13 SAOUTF ZERO1 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=3 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29'
+ as='int((1 + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)'
+ nrd='0.29 / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7 SAOUT ZERO2 net6 VSS sky130_fd_pr__nfet_01v8_lvt L=3 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM12 SAOUT ZERO2 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=3 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29'
+ as='int((1 + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)'
+ nrd='0.29 / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2 OUTDIFF ZERO0 net2 VSS sky130_fd_pr__nfet_01v8_lvt L=3 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM14 OUTDIFF ZERO0 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=3 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29'
+ as='int((1 + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)'
+ nrd='0.29 / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM27 GN1 GP2 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
vpdiff VCC net7 0
.save i(vpdiff)
VVSS net9 0 0
R1 VSS net9 30 m=1
C6 VSS 0 100p m=1
VVCC net10 0 'VCC'
R2 VCC net10 30 m=1
C11 VCC 0 100p m=1
VPLUS PLUS 0 'VDL'
VMINUS MINUS 0 pwl 0 'VDL' 70.2n 'VDL' 70.5n 'VDL-DELTA' 109.9n 'VDL-DELTA' 110.1n 'VDL' 170.2n 'VDL'
+ 170.5n 'VDL+DELTA' 209.9n 'VDL+DELTA' 210.1n 'VDL'
VCAL CAL 0 dc 'VCC' pwl 0 0 29.9n 0 30.1n 'VCC' 69.9n 'VCC' 70.1n 0 129.9n 0 130.1n 'VCC' 169.9n 'VCC'
+ 170.1n 0
VEN EN 0 dc 'VCC' pwl 0 0 29.9n 0 30.1n 'VCC' 109.9n 'VCC' 110.1n 0 129.9n 0 130.1n 'VCC' 209.9n 'VCC'
+ 210.1n 0
E5 TEMPERAT VSS VOL=' temper '
* noconn TEMPERAT
v2 net8 VSSI 0
.save i(v2)
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt_mm
**** end user architecture code
**.ends

* expanding   symbol:  sky130_tests/not.sym # of pins=2
** sym_path: sky130_tests/not.sym
** sch_path: sky130_tests/not.sch
.subckt not y a VCCPIN VSSPIN     W_N=1 L_N=0.15 W_P=2 L_P=0.15
*.opin y
*.ipin a
XM1 DN a VSSPIN VSSPIN sky130_fd_pr__nfet_01v8 L=L_N W=W_N nf=1 ad='int((1 + 1)/2) * W_N / 1 * 0.29'
+ as='int((1 + 2)/2) * W_N / 1 * 0.29' pd='2*int((1 + 1)/2) * (W_N / 1 + 0.29)' ps='2*int((1 + 2)/2) * (W_N / 1 + 0.29)'
+ nrd='0.29 / W_N ' nrs='0.29 / W_N ' sa=0 sb=0 sd=0 mult=1 m=1
XM2 DP a VCCPIN VCCPIN sky130_fd_pr__pfet_01v8 L=L_P W=W_P nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
Vmeas DP y 0
.save i(vmeas)
Vmeas1 y DN 0
.save i(vmeas1)
.save v(dp)
.save v(dn)
.ends


* expanding   symbol:  sky130_tests/passgate.sym # of pins=4
** sym_path: sky130_tests/passgate.sym
** sch_path: sky130_tests/passgate.sch
.subckt passgate Z A GP GN VCCBPIN VSSBPIN  W_N=1 L_N=0.2 W_P=1 L_P=0.2

*.iopin A
*.iopin Z
*.ipin GP
*.ipin GN
XM1 A GN Z VSS sky130_fd_pr__nfet_01v8 W=W_N L=L_N ad='W * 0.29' pd='W + 2 * 0.29' as='W * 0.29' ps='W + 2 * 0.29'
+ nrd=0 nrs=0 sa=0 sb=0 sd=0 nf=1 mult=1
XM2 A GP Z VCC sky130_fd_pr__pfet_01v8 W=W_P L=L_P ad='W * 0.29' pd='W + 2 * 0.29' as='W * 0.29' ps='W + 2 * 0.29'
+ nrd=0 nrs=0 sa=0 sb=0 sd=0 nf=1 mult=1
.ends

**** begin user architecture code


** this experimental option enables mos model bin
** selection based on W/NF instead of W
.option chgtol=4e-16 method=gear
.param VCCGAUSS = agauss(1.8, 0.05, 1)
.param VCC = 'VCCGAUSS'
** use following line to remove VCC variations
* .param VCC = 1.8
.param VDLGAUSS = agauss(0.9, 0.23, 1)
.param VDL = VDLGAUSS
** use following line to remove input common mode variations
* .param VDL =  0.9
.param TEMPGAUSS = agauss(40, 30, 1)
.option temp = 'TEMPGAUSS'
** use following line to remove temperature variations
* .option temp = 25
.param DELTA = 0.002
.control
  setseed  8
  reset
  let run = 1
  save all
  op
  write test_comparator.raw
  reset
  set appendwrite
  dowhile run < = 100
    save saout cal i(vvcc) en plus minus temperat vcc vss gp1 gp2 gn1 gn2 vssi
    + outdiff saoutf zero0 zero1 zero2 sn sp i(vndiff) i(vpdiff)
    + i(v3) i(v2) i(v1) i(v4) i(v5) i(v6)
    * save all
    tran 0.1n 250n uic
    write test_comparator.raw
    let run = run + 1
    reset
  end
  quit 0
.endc


**** end user architecture code
.end
