v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {gnd.sym} 0 0 0 0 {name=g1 lab=0}
C {gnd.sym} 200 0 0 0 {name=g2 lab=0}
C {gnd.sym} 400 0 0 0 {name=g3 lab=0}
