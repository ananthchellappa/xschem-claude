v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
N 0 0 100 0 {}
N 100 0 200 0 {}
N 200 0 300 0 {}
C {lab_pin.sym} 0 0 0 0 {name=l1 lab=CLK}
