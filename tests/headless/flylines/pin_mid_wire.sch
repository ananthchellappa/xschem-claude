v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
N 0 0 200 0 {}
C {lab_pin.sym} 100 0 0 0 {name=l1 lab=CLK}
C {lab_pin.sym} 500 0 0 0 {name=l2 lab=CLK}
