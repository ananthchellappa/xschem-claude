v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
N 0 0 100 0 {lab=CLK}
N 300 0 400 0 {lab=CLK}
C {lab_pin.sym} 0 0 0 0 {name=l1 lab=CLK}
C {lab_pin.sym} 400 0 0 0 {name=l2 lab=CLK}
