v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {lab_pin.sym} 0 0 0 0 {name=l1 lab=CLK}
C {lab_pin.sym} 200 0 0 0 {name=l2 lab=CLK}
