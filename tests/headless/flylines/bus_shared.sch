v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {lab_pin.sym} 0 0 0 0 {name=l1 lab=A[1:0]}
C {lab_pin.sym} 200 0 0 0 {name=l2 lab=A[1:0]}
C {lab_pin.sym} 400 0 0 0 {name=l3 lab=A[0]}
