v {xschem version=3.4.4 file_version=1.2}
G {}
V {}
S {}
E {}
N 200 200 300 200 {}
C {descend_child.sym} 0 0 0 0 {name=x1}
