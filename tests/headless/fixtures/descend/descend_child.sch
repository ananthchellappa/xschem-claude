v {xschem version=3.4.4 file_version=1.2}
G {}
V {}
S {}
E {}
N 0 0 0 -100 {}
N 0 0 100 0 {}
N 0 0 -100 0 {}
