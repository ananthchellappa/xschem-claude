v {xschem version=3.4.4 file_version=1.2}
G {}
V {}
S {}
E {}
N 0 0 200 0 {}
N 200 60 300 60 {}
C {devices/ipin.sym} 0 0 0 0 {name=p1 lab=A}
C {devices/lab_pin.sym} 300 60 0 0 {name=l1 lab=net5}
C {devices/res.sym} 200 30 0 0 {name=R1 value=1k}
C {devices/gnd.sym} 300 90 0 0 {name=l3 lab=0}
