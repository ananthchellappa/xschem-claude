v {xschem version=3.4.4 file_version=1.2}
G {}
V {}
S {}
E {}
N 0 0 100 0 {}
T {VIEW=schematic_old} -40 -140 0 0 0.3 0.3 {}
