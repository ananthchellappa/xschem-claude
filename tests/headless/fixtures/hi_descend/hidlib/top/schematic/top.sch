v {xschem version=3.4.4 file_version=1.2}
G {}
V {}
S {}
E {}
N 200 200 300 200 {}
C {hidlib/leaf} 0 0 0 0 {name=x1}
C {hidlib/leaf} 0 -200 0 0 {name=xb[1:0]}
