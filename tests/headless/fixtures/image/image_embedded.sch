v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -100 -100 100 100 {flags=image,unscaled
alpha=0.8
image_data=iVBORw0KGgoAAAANSUhEUgAAAAQAAAAECAYAAACp8Z5+AAAAO0lEQVR42g3IoQEAMAgDsOrpaTQazRHoaY7gEt7tKmICAHQpGQFCEYcVlxOmaEVfVjunU7GKNdYmZx8/9MoZydZkkUsAAAAASUVORK5CYII=}
