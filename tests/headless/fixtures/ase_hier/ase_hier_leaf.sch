** sch_path: tests/headless/fixtures/ase_hier/ase_hier_leaf.sch
**.subckt ase_hier_leaf A B
*.ipin A
*.opin B
V1 A mid 0
R1 mid 0 1k m=1
**.ends
.end
