v {xschem version=3.4.4 file_version=1.2}
G {}
V {}
S {}
E {}
N 0 0 100 0 {}
C {devices/ipin.sym} 0 0 0 0 {name=p1 lab=A}
C {ase_hier_leaf.sym} 120 0 0 0 {name=x2}
