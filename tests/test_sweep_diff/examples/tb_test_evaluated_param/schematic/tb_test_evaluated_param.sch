** sch_path: tests/test_sweep_diff/examples/tb_test_evaluated_param/schematic/tb_test_evaluated_param.sch
**.subckt tb_test_evaluated_param
x1 A Z2 test_evaluated_param2
V1 A GND pwl 0 0 10n 0 11n $VCC
x2 A Z1 test_evaluated_param1
**** begin user architecture code


.options savecurrents
** following .param is set with a TCL command
.param VCC=[set VCC 3]
.control
  save all
  tran 10p 50n
  write tb_test_evaluated_param.raw
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
