v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -20 -60 70 -60 {lab=A}
N 70 -60 70 0 {lab=A}
N -20 0 70 0 {lab=A}
N -20 0 -20 60 {lab=A}
N -20 60 70 60 {lab=A}
C {devices/ipin} -20 -60 0 0 {name=p1 lab=A}
C {devices/ipin} -20 30 0 0 {name=p2 lab=B}
C {devices/lab_pin} -20 0 0 0 {name=l1 lab=a}
C {devices/lab_pin} -20 60 0 0 {name=l2 lab=b}
