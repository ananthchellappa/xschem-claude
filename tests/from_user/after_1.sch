** sch_path: tests/from_user/after_1.sch
**.subckt after_1 OUT
*.opin OUT
C12 net3 net2 40u m=1
R18 net2 net1 200 m=1
v8 net1 OUT 0
.save i(v8)
**.ends
.end
