v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 100 60 100 70 {lab=#net1}
N 100 60 130 60 {lab=#net1}
N 130 60 130 90 {lab=#net1}
C {devices/res} 100 100 0 0 {name=R1}
