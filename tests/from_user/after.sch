** sch_path: tests/from_user/after.sch
**.subckt after OUT
*.opin OUT
C12 net2 net1 40u m=1
R18 net1 OUT 200 m=1
v8 OUT OUT 0
.save i(v8)
**.ends
.end
