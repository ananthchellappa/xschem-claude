v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {devices/ipin.sym} -40 0 0 0 {name=p1 lab=A}
N -40 0 40 0 {lab=A}
C {devices/lab_pin.sym} 40 -60 0 0 {name=l1 lab=buried_d}
N 40 -60 120 -60 {lab=buried_d}
C {devices/lab_pin.sym} 40 -100 0 0 {name=l2 lab=buried_d2}
N 40 -100 120 -100 {lab=buried_d2}
