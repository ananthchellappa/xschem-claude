v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {c.sym} 60 0 0 0 {name=x_c}
C {devices/ipin.sym} -40 0 0 0 {name=p1 lab=A}
N -40 0 30 0 {lab=A}
