v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {b.sym} 60 0 0 0 {name=x_b}
