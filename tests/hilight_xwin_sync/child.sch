v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {devices/ipin.sym} -40 0 0 0 {name=p1 lab=FOO}
N -40 0 30 0 {lab=FOO}
C {grandchild.sym} 60 -60 0 0 {name=xg}
C {devices/lab_pin.sym} 30 -60 0 0 {name=l2 lab=BAR}
