v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {devices/ipin.sym} -40 0 0 0 {name=p1 lab=BAR}
N -40 0 30 0 {lab=BAR}
C {devices/ipin.sym} -40 -30 0 0 {name=p2 lab=CTRL}
N -40 -30 30 -30 {lab=CTRL}
