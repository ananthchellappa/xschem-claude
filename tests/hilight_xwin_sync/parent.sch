v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {child.sym} 60 0 0 0 {name=xi}
C {devices/lab_pin.sym} 30 0 0 0 {name=l1 lab=FOO}
C {devices/lab_pin.sym} 90 0 0 0 {name=l3 lab=CTRL}
