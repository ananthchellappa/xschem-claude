** sch_path: xschem_libs_newsym/rom8k/rom3_array_ref/schematic/rom3_array_ref.sch
* Copyright (C) 1998-2024 Stefan Frederik Schippers
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
* This program is distributed in the hope that it will be useful,
* but WITHOUT ANY WARRANTY; without even the implied warranty of
* MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
* GNU General Public License for more details.
* You should have received a copy of the GNU General Public License
* along with this program; if not, write to the Free Software
**.subckt rom3_array_ref
*+ LDWL[511],LDWL[510],LDWL[509],LDWL[508],LDWL[507],LDWL[506],LDWL[505],LDWL[504],LDWL[503],LDWL[502],LDWL[501],LDWL[500],LDWL[499],LDWL[498],LDWL[497],LDWL[496],LDWL[495],LDWL[494],LDWL[493],LDWL[492],LDWL[491],LDWL[490],LDWL[489],LDWL[488],LDWL[487],LDWL[486],LDWL[485],LDWL[484],LDWL[483],LDWL[482],LDWL[481],LDWL[480],LDWL[479],LDWL[478],LDWL[477],LDWL[476],LDWL[475],LDWL[474],LDWL[473],LDWL[472],LDWL[471],LDWL[470],LDWL[469],LDWL[468],LDWL[467],LDWL[466],LDWL[465],LDWL[464],LDWL[463],LDWL[462],LDWL[461],LDWL[460],LDWL[459],LDWL[458],LDWL[457],LDWL[456],LDWL[455],LDWL[454],LDWL[453],LDWL[452],LDWL[451],LDWL[450],LDWL[449],LDWL[448],LDWL[447],LDWL[446],LDWL[445],LDWL[444],LDWL[443],LDWL[442],LDWL[441],LDWL[440],LDWL[439],LDWL[438],LDWL[437],LDWL[436],LDWL[435],LDWL[434],LDWL[433],LDWL[432],LDWL[431],LDWL[430],LDWL[429],LDWL[428],LDWL[427],LDWL[426],LDWL[425],LDWL[424],LDWL[423],LDWL[422],LDWL[421],LDWL[420],LDWL[419],LDWL[418],LDWL[417],LDWL[416],LDWL[415],LDWL[414],LDWL[413],LDWL[412],LDWL[411],LDWL[410],LDWL[409],LDWL[408],LDWL[407],LDWL[406],LDWL[405],LDWL[404],LDWL[403],LDWL[402],LDWL[401],LDWL[400],LDWL[399],LDWL[398],LDWL[397],LDWL[396],LDWL[395],LDWL[394],LDWL[393],LDWL[392],LDWL[391],LDWL[390],LDWL[389],LDWL[388],LDWL[387],LDWL[386],LDWL[385],LDWL[384],LDWL[383],LDWL[382],LDWL[381],LDWL[380],LDWL[379],LDWL[378],LDWL[377],LDWL[376],LDWL[375],LDWL[374],LDWL[373],LDWL[372],LDWL[371],LDWL[370],LDWL[369],LDWL[368],LDWL[367],LDWL[366],LDWL[365],LDWL[364],LDWL[363],LDWL[362],LDWL[361],LDWL[360],LDWL[359],LDWL[358],LDWL[357],LDWL[356],LDWL[355],LDWL[354],LDWL[353],LDWL[352],LDWL[351],LDWL[350],LDWL[349],LDWL[348],LDWL[347],LDWL[346],LDWL[345],LDWL[344],LDWL[343],LDWL[342],LDWL[341],LDWL[340],LDWL[339],LDWL[338],LDWL[337],LDWL[336],LDWL[335],LDWL[334],LDWL[333],LDWL[332],LDWL[331],LDWL[330],LDWL[329],LDWL[328],LDWL[327],LDWL[326],LDWL[325],LDWL[324],LDWL[323],LDWL[322],LDWL[321],LDWL[320],LDWL[319],LDWL[318],LDWL[317],LDWL[316],LDWL[315],LDWL[314],LDWL[313],LDWL[312],LDWL[311],LDWL[310],LDWL[309],LDWL[308],LDWL[307],LDWL[306],LDWL[305],LDWL[304],LDWL[303],LDWL[302],LDWL[301],LDWL[300],LDWL[299],LDWL[298],LDWL[297],LDWL[296],LDWL[295],LDWL[294],LDWL[293],LDWL[292],LDWL[291],LDWL[290],LDWL[289],LDWL[288],LDWL[287],LDWL[286],LDWL[285],LDWL[284],LDWL[283],LDWL[282],LDWL[281],LDWL[280],LDWL[279],LDWL[278],LDWL[277],LDWL[276],LDWL[275],LDWL[274],LDWL[273],LDWL[272],LDWL[271],LDWL[270],LDWL[269],LDWL[268],LDWL[267],LDWL[266],LDWL[265],LDWL[264],LDWL[263],LDWL[262],LDWL[261],LDWL[260],LDWL[259],LDWL[258],LDWL[257],LDWL[256],LDWL[255],LDWL[254],LDWL[253],LDWL[252],LDWL[251],LDWL[250],LDWL[249],LDWL[248],LDWL[247],LDWL[246],LDWL[245],LDWL[244],LDWL[243],LDWL[242],LDWL[241],LDWL[240],LDWL[239],LDWL[238],LDWL[237],LDWL[236],LDWL[235],LDWL[234],LDWL[233],LDWL[232],LDWL[231],LDWL[230],LDWL[229],LDWL[228],LDWL[227],LDWL[226],LDWL[225],LDWL[224],LDWL[223],LDWL[222],LDWL[221],LDWL[220],LDWL[219],LDWL[218],LDWL[217],LDWL[216],LDWL[215],LDWL[214],LDWL[213],LDWL[212],LDWL[211],LDWL[210],LDWL[209],LDWL[208],LDWL[207],LDWL[206],LDWL[205],LDWL[204],LDWL[203],LDWL[202],LDWL[201],LDWL[200],LDWL[199],LDWL[198],LDWL[197],LDWL[196],LDWL[195],LDWL[194],LDWL[193],LDWL[192],LDWL[191],LDWL[190],LDWL[189],LDWL[188],LDWL[187],LDWL[186],LDWL[185],LDWL[184],LDWL[183],LDWL[182],LDWL[181],LDWL[180],LDWL[179],LDWL[178],LDWL[177],LDWL[176],LDWL[175],LDWL[174],LDWL[173],LDWL[172],LDWL[171],LDWL[170],LDWL[169],LDWL[168],LDWL[167],LDWL[166],LDWL[165],LDWL[164],LDWL[163],LDWL[162],LDWL[161],LDWL[160],LDWL[159],LDWL[158],LDWL[157],LDWL[156],LDWL[155],LDWL[154],LDWL[153],LDWL[152],LDWL[151],LDWL[150],LDWL[149],LDWL[148],LDWL[147],LDWL[146],LDWL[145],LDWL[144],LDWL[143],LDWL[142],LDWL[141],LDWL[140],LDWL[139],LDWL[138],LDWL[137],LDWL[136],LDWL[135],LDWL[134],LDWL[133],LDWL[132],LDWL[131],LDWL[130],LDWL[129],LDWL[128],LDWL[127],LDWL[126],LDWL[125],LDWL[124],LDWL[123],LDWL[122],LDWL[121],LDWL[120],LDWL[119],LDWL[118],LDWL[117],LDWL[116],LDWL[115],LDWL[114],LDWL[113],LDWL[112],LDWL[111],LDWL[110],LDWL[109],LDWL[108],LDWL[107],LDWL[106],LDWL[105],LDWL[104],LDWL[103],LDWL[102],LDWL[101],LDWL[100],LDWL[99],LDWL[98],LDWL[97],LDWL[96],LDWL[95],LDWL[94],LDWL[93],LDWL[92],LDWL[91],LDWL[90],LDWL[89],LDWL[88],LDWL[87],LDWL[86],LDWL[85],LDWL[84],LDWL[83],LDWL[82],LDWL[81],LDWL[80],LDWL[79],LDWL[78],LDWL[77],LDWL[76],LDWL[75],LDWL[74],LDWL[73],LDWL[72],LDWL[71],LDWL[70],LDWL[69],LDWL[68],LDWL[67],LDWL[66],LDWL[65],LDWL[64],LDWL[63],LDWL[62],LDWL[61],LDWL[60],LDWL[59],LDWL[58],LDWL[57],LDWL[56],LDWL[55],LDWL[54],LDWL[53],LDWL[52],LDWL[51],LDWL[50],LDWL[49],LDWL[48],LDWL[47],LDWL[46],LDWL[45],LDWL[44],LDWL[43],LDWL[42],LDWL[41],LDWL[40],LDWL[39],LDWL[38],LDWL[37],LDWL[36],LDWL[35],LDWL[34],LDWL[33],LDWL[32],LDWL[31],LDWL[30],LDWL[29],LDWL[28],LDWL[27],LDWL[26],LDWL[25],LDWL[24],LDWL[23],LDWL[22],LDWL[21],LDWL[20],LDWL[19],LDWL[18],LDWL[17],LDWL[16],LDWL[15],LDWL[14],LDWL[13],LDWL[12],LDWL[11],LDWL[10],LDWL[9],LDWL[8],LDWL[7],LDWL[6],LDWL[5],LDWL[4],LDWL[3],LDWL[2],LDWL[1],LDWL[0] vss LDBLREF
*.ipin
*+ LDWL[511],LDWL[510],LDWL[509],LDWL[508],LDWL[507],LDWL[506],LDWL[505],LDWL[504],LDWL[503],LDWL[502],LDWL[501],LDWL[500],LDWL[499],LDWL[498],LDWL[497],LDWL[496],LDWL[495],LDWL[494],LDWL[493],LDWL[492],LDWL[491],LDWL[490],LDWL[489],LDWL[488],LDWL[487],LDWL[486],LDWL[485],LDWL[484],LDWL[483],LDWL[482],LDWL[481],LDWL[480],LDWL[479],LDWL[478],LDWL[477],LDWL[476],LDWL[475],LDWL[474],LDWL[473],LDWL[472],LDWL[471],LDWL[470],LDWL[469],LDWL[468],LDWL[467],LDWL[466],LDWL[465],LDWL[464],LDWL[463],LDWL[462],LDWL[461],LDWL[460],LDWL[459],LDWL[458],LDWL[457],LDWL[456],LDWL[455],LDWL[454],LDWL[453],LDWL[452],LDWL[451],LDWL[450],LDWL[449],LDWL[448],LDWL[447],LDWL[446],LDWL[445],LDWL[444],LDWL[443],LDWL[442],LDWL[441],LDWL[440],LDWL[439],LDWL[438],LDWL[437],LDWL[436],LDWL[435],LDWL[434],LDWL[433],LDWL[432],LDWL[431],LDWL[430],LDWL[429],LDWL[428],LDWL[427],LDWL[426],LDWL[425],LDWL[424],LDWL[423],LDWL[422],LDWL[421],LDWL[420],LDWL[419],LDWL[418],LDWL[417],LDWL[416],LDWL[415],LDWL[414],LDWL[413],LDWL[412],LDWL[411],LDWL[410],LDWL[409],LDWL[408],LDWL[407],LDWL[406],LDWL[405],LDWL[404],LDWL[403],LDWL[402],LDWL[401],LDWL[400],LDWL[399],LDWL[398],LDWL[397],LDWL[396],LDWL[395],LDWL[394],LDWL[393],LDWL[392],LDWL[391],LDWL[390],LDWL[389],LDWL[388],LDWL[387],LDWL[386],LDWL[385],LDWL[384],LDWL[383],LDWL[382],LDWL[381],LDWL[380],LDWL[379],LDWL[378],LDWL[377],LDWL[376],LDWL[375],LDWL[374],LDWL[373],LDWL[372],LDWL[371],LDWL[370],LDWL[369],LDWL[368],LDWL[367],LDWL[366],LDWL[365],LDWL[364],LDWL[363],LDWL[362],LDWL[361],LDWL[360],LDWL[359],LDWL[358],LDWL[357],LDWL[356],LDWL[355],LDWL[354],LDWL[353],LDWL[352],LDWL[351],LDWL[350],LDWL[349],LDWL[348],LDWL[347],LDWL[346],LDWL[345],LDWL[344],LDWL[343],LDWL[342],LDWL[341],LDWL[340],LDWL[339],LDWL[338],LDWL[337],LDWL[336],LDWL[335],LDWL[334],LDWL[333],LDWL[332],LDWL[331],LDWL[330],LDWL[329],LDWL[328],LDWL[327],LDWL[326],LDWL[325],LDWL[324],LDWL[323],LDWL[322],LDWL[321],LDWL[320],LDWL[319],LDWL[318],LDWL[317],LDWL[316],LDWL[315],LDWL[314],LDWL[313],LDWL[312],LDWL[311],LDWL[310],LDWL[309],LDWL[308],LDWL[307],LDWL[306],LDWL[305],LDWL[304],LDWL[303],LDWL[302],LDWL[301],LDWL[300],LDWL[299],LDWL[298],LDWL[297],LDWL[296],LDWL[295],LDWL[294],LDWL[293],LDWL[292],LDWL[291],LDWL[290],LDWL[289],LDWL[288],LDWL[287],LDWL[286],LDWL[285],LDWL[284],LDWL[283],LDWL[282],LDWL[281],LDWL[280],LDWL[279],LDWL[278],LDWL[277],LDWL[276],LDWL[275],LDWL[274],LDWL[273],LDWL[272],LDWL[271],LDWL[270],LDWL[269],LDWL[268],LDWL[267],LDWL[266],LDWL[265],LDWL[264],LDWL[263],LDWL[262],LDWL[261],LDWL[260],LDWL[259],LDWL[258],LDWL[257],LDWL[256],LDWL[255],LDWL[254],LDWL[253],LDWL[252],LDWL[251],LDWL[250],LDWL[249],LDWL[248],LDWL[247],LDWL[246],LDWL[245],LDWL[244],LDWL[243],LDWL[242],LDWL[241],LDWL[240],LDWL[239],LDWL[238],LDWL[237],LDWL[236],LDWL[235],LDWL[234],LDWL[233],LDWL[232],LDWL[231],LDWL[230],LDWL[229],LDWL[228],LDWL[227],LDWL[226],LDWL[225],LDWL[224],LDWL[223],LDWL[222],LDWL[221],LDWL[220],LDWL[219],LDWL[218],LDWL[217],LDWL[216],LDWL[215],LDWL[214],LDWL[213],LDWL[212],LDWL[211],LDWL[210],LDWL[209],LDWL[208],LDWL[207],LDWL[206],LDWL[205],LDWL[204],LDWL[203],LDWL[202],LDWL[201],LDWL[200],LDWL[199],LDWL[198],LDWL[197],LDWL[196],LDWL[195],LDWL[194],LDWL[193],LDWL[192],LDWL[191],LDWL[190],LDWL[189],LDWL[188],LDWL[187],LDWL[186],LDWL[185],LDWL[184],LDWL[183],LDWL[182],LDWL[181],LDWL[180],LDWL[179],LDWL[178],LDWL[177],LDWL[176],LDWL[175],LDWL[174],LDWL[173],LDWL[172],LDWL[171],LDWL[170],LDWL[169],LDWL[168],LDWL[167],LDWL[166],LDWL[165],LDWL[164],LDWL[163],LDWL[162],LDWL[161],LDWL[160],LDWL[159],LDWL[158],LDWL[157],LDWL[156],LDWL[155],LDWL[154],LDWL[153],LDWL[152],LDWL[151],LDWL[150],LDWL[149],LDWL[148],LDWL[147],LDWL[146],LDWL[145],LDWL[144],LDWL[143],LDWL[142],LDWL[141],LDWL[140],LDWL[139],LDWL[138],LDWL[137],LDWL[136],LDWL[135],LDWL[134],LDWL[133],LDWL[132],LDWL[131],LDWL[130],LDWL[129],LDWL[128],LDWL[127],LDWL[126],LDWL[125],LDWL[124],LDWL[123],LDWL[122],LDWL[121],LDWL[120],LDWL[119],LDWL[118],LDWL[117],LDWL[116],LDWL[115],LDWL[114],LDWL[113],LDWL[112],LDWL[111],LDWL[110],LDWL[109],LDWL[108],LDWL[107],LDWL[106],LDWL[105],LDWL[104],LDWL[103],LDWL[102],LDWL[101],LDWL[100],LDWL[99],LDWL[98],LDWL[97],LDWL[96],LDWL[95],LDWL[94],LDWL[93],LDWL[92],LDWL[91],LDWL[90],LDWL[89],LDWL[88],LDWL[87],LDWL[86],LDWL[85],LDWL[84],LDWL[83],LDWL[82],LDWL[81],LDWL[80],LDWL[79],LDWL[78],LDWL[77],LDWL[76],LDWL[75],LDWL[74],LDWL[73],LDWL[72],LDWL[71],LDWL[70],LDWL[69],LDWL[68],LDWL[67],LDWL[66],LDWL[65],LDWL[64],LDWL[63],LDWL[62],LDWL[61],LDWL[60],LDWL[59],LDWL[58],LDWL[57],LDWL[56],LDWL[55],LDWL[54],LDWL[53],LDWL[52],LDWL[51],LDWL[50],LDWL[49],LDWL[48],LDWL[47],LDWL[46],LDWL[45],LDWL[44],LDWL[43],LDWL[42],LDWL[41],LDWL[40],LDWL[39],LDWL[38],LDWL[37],LDWL[36],LDWL[35],LDWL[34],LDWL[33],LDWL[32],LDWL[31],LDWL[30],LDWL[29],LDWL[28],LDWL[27],LDWL[26],LDWL[25],LDWL[24],LDWL[23],LDWL[22],LDWL[21],LDWL[20],LDWL[19],LDWL[18],LDWL[17],LDWL[16],LDWL[15],LDWL[14],LDWL[13],LDWL[12],LDWL[11],LDWL[10],LDWL[9],LDWL[8],LDWL[7],LDWL[6],LDWL[5],LDWL[4],LDWL[3],LDWL[2],LDWL[1],LDWL[0]
*.ipin vss
*.iopin LDBLREF
c1 LDBLREF 0 180f m=1
**** begin user architecture code
* PARASITICS


* reference bl


mr0 LDBLREF LDWL[0] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr1 LDBLREF LDWL[1] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr2 LDBLREF LDWL[2] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr3 LDBLREF LDWL[3] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr4 LDBLREF LDWL[4] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr5 LDBLREF LDWL[5] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr6 LDBLREF LDWL[6] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr7 LDBLREF LDWL[7] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr8 LDBLREF LDWL[8] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr9 LDBLREF LDWL[9] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
mr10 LDBLREF LDWL[10] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr11 LDBLREF LDWL[11] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr12 LDBLREF LDWL[12] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr13 LDBLREF LDWL[13] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr14 LDBLREF LDWL[14] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr15 LDBLREF LDWL[15] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr16 LDBLREF LDWL[16] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr17 LDBLREF LDWL[17] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr18 LDBLREF LDWL[18] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr19 LDBLREF LDWL[19] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr20 LDBLREF LDWL[20] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr21 LDBLREF LDWL[21] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr22 LDBLREF LDWL[22] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr23 LDBLREF LDWL[23] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr24 LDBLREF LDWL[24] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr25 LDBLREF LDWL[25] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr26 LDBLREF LDWL[26] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr27 LDBLREF LDWL[27] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr28 LDBLREF LDWL[28] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr29 LDBLREF LDWL[29] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr30 LDBLREF LDWL[30] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr31 LDBLREF LDWL[31] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr32 LDBLREF LDWL[32] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr33 LDBLREF LDWL[33] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr34 LDBLREF LDWL[34] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr35 LDBLREF LDWL[35] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr36 LDBLREF LDWL[36] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr37 LDBLREF LDWL[37] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr38 LDBLREF LDWL[38] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr39 LDBLREF LDWL[39] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr40 LDBLREF LDWL[40] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr41 LDBLREF LDWL[41] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr42 LDBLREF LDWL[42] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr43 LDBLREF LDWL[43] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr44 LDBLREF LDWL[44] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr45 LDBLREF LDWL[45] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr46 LDBLREF LDWL[46] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr47 LDBLREF LDWL[47] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr48 LDBLREF LDWL[48] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr49 LDBLREF LDWL[49] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr50 LDBLREF LDWL[50] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr51 LDBLREF LDWL[51] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr52 LDBLREF LDWL[52] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr53 LDBLREF LDWL[53] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr54 LDBLREF LDWL[54] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr55 LDBLREF LDWL[55] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr56 LDBLREF LDWL[56] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr57 LDBLREF LDWL[57] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr58 LDBLREF LDWL[58] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr59 LDBLREF LDWL[59] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr60 LDBLREF LDWL[60] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr61 LDBLREF LDWL[61] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr62 LDBLREF LDWL[62] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr63 LDBLREF LDWL[63] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr64 LDBLREF LDWL[64] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr65 LDBLREF LDWL[65] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr66 LDBLREF LDWL[66] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr67 LDBLREF LDWL[67] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr68 LDBLREF LDWL[68] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr69 LDBLREF LDWL[69] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr70 LDBLREF LDWL[70] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr71 LDBLREF LDWL[71] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr72 LDBLREF LDWL[72] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr73 LDBLREF LDWL[73] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr74 LDBLREF LDWL[74] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr75 LDBLREF LDWL[75] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr76 LDBLREF LDWL[76] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr77 LDBLREF LDWL[77] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr78 LDBLREF LDWL[78] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr79 LDBLREF LDWL[79] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr80 LDBLREF LDWL[80] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr81 LDBLREF LDWL[81] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr82 LDBLREF LDWL[82] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr83 LDBLREF LDWL[83] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr84 LDBLREF LDWL[84] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr85 LDBLREF LDWL[85] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr86 LDBLREF LDWL[86] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr87 LDBLREF LDWL[87] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr88 LDBLREF LDWL[88] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr89 LDBLREF LDWL[89] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr90 LDBLREF LDWL[90] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr91 LDBLREF LDWL[91] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr92 LDBLREF LDWL[92] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr93 LDBLREF LDWL[93] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr94 LDBLREF LDWL[94] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr95 LDBLREF LDWL[95] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr96 LDBLREF LDWL[96] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr97 LDBLREF LDWL[97] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr98 LDBLREF LDWL[98] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr99 LDBLREF LDWL[99] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr100 LDBLREF LDWL[100] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr101 LDBLREF LDWL[101] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr102 LDBLREF LDWL[102] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr103 LDBLREF LDWL[103] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr104 LDBLREF LDWL[104] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr105 LDBLREF LDWL[105] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr106 LDBLREF LDWL[106] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr107 LDBLREF LDWL[107] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr108 LDBLREF LDWL[108] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr109 LDBLREF LDWL[109] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr110 LDBLREF LDWL[110] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr111 LDBLREF LDWL[111] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr112 LDBLREF LDWL[112] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr113 LDBLREF LDWL[113] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr114 LDBLREF LDWL[114] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr115 LDBLREF LDWL[115] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr116 LDBLREF LDWL[116] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr117 LDBLREF LDWL[117] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr118 LDBLREF LDWL[118] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr119 LDBLREF LDWL[119] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr120 LDBLREF LDWL[120] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr121 LDBLREF LDWL[121] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr122 LDBLREF LDWL[122] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr123 LDBLREF LDWL[123] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr124 LDBLREF LDWL[124] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr125 LDBLREF LDWL[125] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr126 LDBLREF LDWL[126] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr127 LDBLREF LDWL[127] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr128 LDBLREF LDWL[128] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr129 LDBLREF LDWL[129] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr130 LDBLREF LDWL[130] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr131 LDBLREF LDWL[131] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr132 LDBLREF LDWL[132] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr133 LDBLREF LDWL[133] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr134 LDBLREF LDWL[134] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr135 LDBLREF LDWL[135] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr136 LDBLREF LDWL[136] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr137 LDBLREF LDWL[137] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr138 LDBLREF LDWL[138] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr139 LDBLREF LDWL[139] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr140 LDBLREF LDWL[140] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr141 LDBLREF LDWL[141] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr142 LDBLREF LDWL[142] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr143 LDBLREF LDWL[143] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr144 LDBLREF LDWL[144] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr145 LDBLREF LDWL[145] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr146 LDBLREF LDWL[146] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr147 LDBLREF LDWL[147] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr148 LDBLREF LDWL[148] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr149 LDBLREF LDWL[149] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr150 LDBLREF LDWL[150] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr151 LDBLREF LDWL[151] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr152 LDBLREF LDWL[152] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr153 LDBLREF LDWL[153] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr154 LDBLREF LDWL[154] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr155 LDBLREF LDWL[155] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr156 LDBLREF LDWL[156] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr157 LDBLREF LDWL[157] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr158 LDBLREF LDWL[158] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr159 LDBLREF LDWL[159] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr160 LDBLREF LDWL[160] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr161 LDBLREF LDWL[161] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr162 LDBLREF LDWL[162] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr163 LDBLREF LDWL[163] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr164 LDBLREF LDWL[164] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr165 LDBLREF LDWL[165] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr166 LDBLREF LDWL[166] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr167 LDBLREF LDWL[167] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr168 LDBLREF LDWL[168] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr169 LDBLREF LDWL[169] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr170 LDBLREF LDWL[170] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr171 LDBLREF LDWL[171] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr172 LDBLREF LDWL[172] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr173 LDBLREF LDWL[173] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr174 LDBLREF LDWL[174] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr175 LDBLREF LDWL[175] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr176 LDBLREF LDWL[176] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr177 LDBLREF LDWL[177] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr178 LDBLREF LDWL[178] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr179 LDBLREF LDWL[179] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr180 LDBLREF LDWL[180] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr181 LDBLREF LDWL[181] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr182 LDBLREF LDWL[182] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr183 LDBLREF LDWL[183] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr184 LDBLREF LDWL[184] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr185 LDBLREF LDWL[185] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr186 LDBLREF LDWL[186] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr187 LDBLREF LDWL[187] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr188 LDBLREF LDWL[188] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr189 LDBLREF LDWL[189] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr190 LDBLREF LDWL[190] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr191 LDBLREF LDWL[191] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr192 LDBLREF LDWL[192] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr193 LDBLREF LDWL[193] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr194 LDBLREF LDWL[194] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr195 LDBLREF LDWL[195] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr196 LDBLREF LDWL[196] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr197 LDBLREF LDWL[197] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr198 LDBLREF LDWL[198] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr199 LDBLREF LDWL[199] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr200 LDBLREF LDWL[200] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr201 LDBLREF LDWL[201] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr202 LDBLREF LDWL[202] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr203 LDBLREF LDWL[203] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr204 LDBLREF LDWL[204] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr205 LDBLREF LDWL[205] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr206 LDBLREF LDWL[206] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr207 LDBLREF LDWL[207] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr208 LDBLREF LDWL[208] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr209 LDBLREF LDWL[209] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr210 LDBLREF LDWL[210] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr211 LDBLREF LDWL[211] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr212 LDBLREF LDWL[212] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr213 LDBLREF LDWL[213] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr214 LDBLREF LDWL[214] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr215 LDBLREF LDWL[215] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr216 LDBLREF LDWL[216] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr217 LDBLREF LDWL[217] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr218 LDBLREF LDWL[218] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr219 LDBLREF LDWL[219] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr220 LDBLREF LDWL[220] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr221 LDBLREF LDWL[221] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr222 LDBLREF LDWL[222] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr223 LDBLREF LDWL[223] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr224 LDBLREF LDWL[224] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr225 LDBLREF LDWL[225] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr226 LDBLREF LDWL[226] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr227 LDBLREF LDWL[227] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr228 LDBLREF LDWL[228] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr229 LDBLREF LDWL[229] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr230 LDBLREF LDWL[230] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr231 LDBLREF LDWL[231] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr232 LDBLREF LDWL[232] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr233 LDBLREF LDWL[233] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr234 LDBLREF LDWL[234] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr235 LDBLREF LDWL[235] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr236 LDBLREF LDWL[236] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr237 LDBLREF LDWL[237] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr238 LDBLREF LDWL[238] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr239 LDBLREF LDWL[239] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr240 LDBLREF LDWL[240] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr241 LDBLREF LDWL[241] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr242 LDBLREF LDWL[242] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr243 LDBLREF LDWL[243] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr244 LDBLREF LDWL[244] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr245 LDBLREF LDWL[245] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr246 LDBLREF LDWL[246] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr247 LDBLREF LDWL[247] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr248 LDBLREF LDWL[248] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr249 LDBLREF LDWL[249] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr250 LDBLREF LDWL[250] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr251 LDBLREF LDWL[251] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr252 LDBLREF LDWL[252] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr253 LDBLREF LDWL[253] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr254 LDBLREF LDWL[254] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr255 LDBLREF LDWL[255] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr256 LDBLREF LDWL[256] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr257 LDBLREF LDWL[257] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr258 LDBLREF LDWL[258] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr259 LDBLREF LDWL[259] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr260 LDBLREF LDWL[260] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr261 LDBLREF LDWL[261] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr262 LDBLREF LDWL[262] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr263 LDBLREF LDWL[263] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr264 LDBLREF LDWL[264] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr265 LDBLREF LDWL[265] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr266 LDBLREF LDWL[266] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr267 LDBLREF LDWL[267] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr268 LDBLREF LDWL[268] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr269 LDBLREF LDWL[269] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr270 LDBLREF LDWL[270] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr271 LDBLREF LDWL[271] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr272 LDBLREF LDWL[272] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr273 LDBLREF LDWL[273] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr274 LDBLREF LDWL[274] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr275 LDBLREF LDWL[275] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr276 LDBLREF LDWL[276] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr277 LDBLREF LDWL[277] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr278 LDBLREF LDWL[278] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr279 LDBLREF LDWL[279] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr280 LDBLREF LDWL[280] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr281 LDBLREF LDWL[281] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr282 LDBLREF LDWL[282] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr283 LDBLREF LDWL[283] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr284 LDBLREF LDWL[284] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr285 LDBLREF LDWL[285] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr286 LDBLREF LDWL[286] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr287 LDBLREF LDWL[287] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr288 LDBLREF LDWL[288] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr289 LDBLREF LDWL[289] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr290 LDBLREF LDWL[290] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr291 LDBLREF LDWL[291] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr292 LDBLREF LDWL[292] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr293 LDBLREF LDWL[293] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr294 LDBLREF LDWL[294] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr295 LDBLREF LDWL[295] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr296 LDBLREF LDWL[296] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr297 LDBLREF LDWL[297] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr298 LDBLREF LDWL[298] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr299 LDBLREF LDWL[299] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr300 LDBLREF LDWL[300] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr301 LDBLREF LDWL[301] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr302 LDBLREF LDWL[302] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr303 LDBLREF LDWL[303] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr304 LDBLREF LDWL[304] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr305 LDBLREF LDWL[305] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr306 LDBLREF LDWL[306] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr307 LDBLREF LDWL[307] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr308 LDBLREF LDWL[308] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr309 LDBLREF LDWL[309] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr310 LDBLREF LDWL[310] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr311 LDBLREF LDWL[311] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr312 LDBLREF LDWL[312] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr313 LDBLREF LDWL[313] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr314 LDBLREF LDWL[314] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr315 LDBLREF LDWL[315] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr316 LDBLREF LDWL[316] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr317 LDBLREF LDWL[317] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr318 LDBLREF LDWL[318] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr319 LDBLREF LDWL[319] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr320 LDBLREF LDWL[320] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr321 LDBLREF LDWL[321] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr322 LDBLREF LDWL[322] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr323 LDBLREF LDWL[323] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr324 LDBLREF LDWL[324] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr325 LDBLREF LDWL[325] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr326 LDBLREF LDWL[326] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr327 LDBLREF LDWL[327] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr328 LDBLREF LDWL[328] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr329 LDBLREF LDWL[329] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr330 LDBLREF LDWL[330] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr331 LDBLREF LDWL[331] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr332 LDBLREF LDWL[332] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr333 LDBLREF LDWL[333] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr334 LDBLREF LDWL[334] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr335 LDBLREF LDWL[335] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr336 LDBLREF LDWL[336] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr337 LDBLREF LDWL[337] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr338 LDBLREF LDWL[338] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr339 LDBLREF LDWL[339] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr340 LDBLREF LDWL[340] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr341 LDBLREF LDWL[341] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr342 LDBLREF LDWL[342] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr343 LDBLREF LDWL[343] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr344 LDBLREF LDWL[344] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr345 LDBLREF LDWL[345] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr346 LDBLREF LDWL[346] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr347 LDBLREF LDWL[347] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr348 LDBLREF LDWL[348] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr349 LDBLREF LDWL[349] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr350 LDBLREF LDWL[350] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr351 LDBLREF LDWL[351] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr352 LDBLREF LDWL[352] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr353 LDBLREF LDWL[353] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr354 LDBLREF LDWL[354] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr355 LDBLREF LDWL[355] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr356 LDBLREF LDWL[356] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr357 LDBLREF LDWL[357] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr358 LDBLREF LDWL[358] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr359 LDBLREF LDWL[359] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr360 LDBLREF LDWL[360] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr361 LDBLREF LDWL[361] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr362 LDBLREF LDWL[362] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr363 LDBLREF LDWL[363] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr364 LDBLREF LDWL[364] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr365 LDBLREF LDWL[365] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr366 LDBLREF LDWL[366] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr367 LDBLREF LDWL[367] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr368 LDBLREF LDWL[368] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr369 LDBLREF LDWL[369] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr370 LDBLREF LDWL[370] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr371 LDBLREF LDWL[371] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr372 LDBLREF LDWL[372] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr373 LDBLREF LDWL[373] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr374 LDBLREF LDWL[374] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr375 LDBLREF LDWL[375] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr376 LDBLREF LDWL[376] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr377 LDBLREF LDWL[377] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr378 LDBLREF LDWL[378] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr379 LDBLREF LDWL[379] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr380 LDBLREF LDWL[380] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr381 LDBLREF LDWL[381] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr382 LDBLREF LDWL[382] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr383 LDBLREF LDWL[383] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr384 LDBLREF LDWL[384] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr385 LDBLREF LDWL[385] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr386 LDBLREF LDWL[386] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr387 LDBLREF LDWL[387] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr388 LDBLREF LDWL[388] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr389 LDBLREF LDWL[389] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr390 LDBLREF LDWL[390] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr391 LDBLREF LDWL[391] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr392 LDBLREF LDWL[392] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr393 LDBLREF LDWL[393] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr394 LDBLREF LDWL[394] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr395 LDBLREF LDWL[395] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr396 LDBLREF LDWL[396] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr397 LDBLREF LDWL[397] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr398 LDBLREF LDWL[398] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr399 LDBLREF LDWL[399] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr400 LDBLREF LDWL[400] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr401 LDBLREF LDWL[401] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr402 LDBLREF LDWL[402] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr403 LDBLREF LDWL[403] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr404 LDBLREF LDWL[404] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr405 LDBLREF LDWL[405] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr406 LDBLREF LDWL[406] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr407 LDBLREF LDWL[407] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr408 LDBLREF LDWL[408] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr409 LDBLREF LDWL[409] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr410 LDBLREF LDWL[410] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr411 LDBLREF LDWL[411] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr412 LDBLREF LDWL[412] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr413 LDBLREF LDWL[413] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr414 LDBLREF LDWL[414] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr415 LDBLREF LDWL[415] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr416 LDBLREF LDWL[416] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr417 LDBLREF LDWL[417] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr418 LDBLREF LDWL[418] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr419 LDBLREF LDWL[419] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr420 LDBLREF LDWL[420] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr421 LDBLREF LDWL[421] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr422 LDBLREF LDWL[422] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr423 LDBLREF LDWL[423] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr424 LDBLREF LDWL[424] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr425 LDBLREF LDWL[425] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr426 LDBLREF LDWL[426] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr427 LDBLREF LDWL[427] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr428 LDBLREF LDWL[428] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr429 LDBLREF LDWL[429] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr430 LDBLREF LDWL[430] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr431 LDBLREF LDWL[431] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr432 LDBLREF LDWL[432] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr433 LDBLREF LDWL[433] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr434 LDBLREF LDWL[434] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr435 LDBLREF LDWL[435] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr436 LDBLREF LDWL[436] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr437 LDBLREF LDWL[437] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr438 LDBLREF LDWL[438] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr439 LDBLREF LDWL[439] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr440 LDBLREF LDWL[440] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr441 LDBLREF LDWL[441] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr442 LDBLREF LDWL[442] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr443 LDBLREF LDWL[443] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr444 LDBLREF LDWL[444] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr445 LDBLREF LDWL[445] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr446 LDBLREF LDWL[446] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr447 LDBLREF LDWL[447] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr448 LDBLREF LDWL[448] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr449 LDBLREF LDWL[449] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr450 LDBLREF LDWL[450] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr451 LDBLREF LDWL[451] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr452 LDBLREF LDWL[452] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr453 LDBLREF LDWL[453] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr454 LDBLREF LDWL[454] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr455 LDBLREF LDWL[455] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr456 LDBLREF LDWL[456] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr457 LDBLREF LDWL[457] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr458 LDBLREF LDWL[458] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr459 LDBLREF LDWL[459] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr460 LDBLREF LDWL[460] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr461 LDBLREF LDWL[461] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr462 LDBLREF LDWL[462] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr463 LDBLREF LDWL[463] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr464 LDBLREF LDWL[464] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr465 LDBLREF LDWL[465] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr466 LDBLREF LDWL[466] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr467 LDBLREF LDWL[467] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr468 LDBLREF LDWL[468] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr469 LDBLREF LDWL[469] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr470 LDBLREF LDWL[470] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr471 LDBLREF LDWL[471] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr472 LDBLREF LDWL[472] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr473 LDBLREF LDWL[473] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr474 LDBLREF LDWL[474] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr475 LDBLREF LDWL[475] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr476 LDBLREF LDWL[476] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr477 LDBLREF LDWL[477] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr478 LDBLREF LDWL[478] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr479 LDBLREF LDWL[479] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr480 LDBLREF LDWL[480] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr481 LDBLREF LDWL[481] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr482 LDBLREF LDWL[482] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr483 LDBLREF LDWL[483] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr484 LDBLREF LDWL[484] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr485 LDBLREF LDWL[485] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr486 LDBLREF LDWL[486] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr487 LDBLREF LDWL[487] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr488 LDBLREF LDWL[488] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr489 LDBLREF LDWL[489] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr490 LDBLREF LDWL[490] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr491 LDBLREF LDWL[491] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr492 LDBLREF LDWL[492] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr493 LDBLREF LDWL[493] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr494 LDBLREF LDWL[494] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr495 LDBLREF LDWL[495] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr496 LDBLREF LDWL[496] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr497 LDBLREF LDWL[497] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr498 LDBLREF LDWL[498] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr499 LDBLREF LDWL[499] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr500 LDBLREF LDWL[500] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr501 LDBLREF LDWL[501] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr502 LDBLREF LDWL[502] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr503 LDBLREF LDWL[503] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr504 LDBLREF LDWL[504] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr505 LDBLREF LDWL[505] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr506 LDBLREF LDWL[506] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr507 LDBLREF LDWL[507] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr508 LDBLREF LDWL[508] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr509 LDBLREF LDWL[509] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr510 LDBLREF LDWL[510] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1
mr511 LDBLREF LDWL[511] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06
+ m=1

* /reference bl

* last bitline


ml0 VSS LDWL[0] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml1 VSS LDWL[1] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml2 VSS LDWL[2] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml3 VSS LDWL[3] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml4 VSS LDWL[4] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml5 VSS LDWL[5] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml6 VSS LDWL[6] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml7 VSS LDWL[7] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml8 VSS LDWL[8] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml9 VSS LDWL[9] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml10 VSS LDWL[10] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml11 VSS LDWL[11] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml12 VSS LDWL[12] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml13 VSS LDWL[13] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml14 VSS LDWL[14] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml15 VSS LDWL[15] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml16 VSS LDWL[16] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml17 VSS LDWL[17] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml18 VSS LDWL[18] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml19 VSS LDWL[19] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml20 VSS LDWL[20] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml21 VSS LDWL[21] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml22 VSS LDWL[22] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml23 VSS LDWL[23] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml24 VSS LDWL[24] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml25 VSS LDWL[25] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml26 VSS LDWL[26] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml27 VSS LDWL[27] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml28 VSS LDWL[28] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml29 VSS LDWL[29] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml30 VSS LDWL[30] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml31 VSS LDWL[31] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml32 VSS LDWL[32] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml33 VSS LDWL[33] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml34 VSS LDWL[34] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml35 VSS LDWL[35] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml36 VSS LDWL[36] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml37 VSS LDWL[37] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml38 VSS LDWL[38] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml39 VSS LDWL[39] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml40 VSS LDWL[40] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml41 VSS LDWL[41] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml42 VSS LDWL[42] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml43 VSS LDWL[43] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml44 VSS LDWL[44] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml45 VSS LDWL[45] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml46 VSS LDWL[46] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml47 VSS LDWL[47] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml48 VSS LDWL[48] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml49 VSS LDWL[49] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml50 VSS LDWL[50] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml51 VSS LDWL[51] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml52 VSS LDWL[52] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml53 VSS LDWL[53] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml54 VSS LDWL[54] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml55 VSS LDWL[55] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml56 VSS LDWL[56] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml57 VSS LDWL[57] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml58 VSS LDWL[58] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml59 VSS LDWL[59] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml60 VSS LDWL[60] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml61 VSS LDWL[61] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml62 VSS LDWL[62] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml63 VSS LDWL[63] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml64 VSS LDWL[64] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml65 VSS LDWL[65] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml66 VSS LDWL[66] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml67 VSS LDWL[67] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml68 VSS LDWL[68] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml69 VSS LDWL[69] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml70 VSS LDWL[70] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml71 VSS LDWL[71] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml72 VSS LDWL[72] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml73 VSS LDWL[73] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml74 VSS LDWL[74] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml75 VSS LDWL[75] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml76 VSS LDWL[76] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml77 VSS LDWL[77] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml78 VSS LDWL[78] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml79 VSS LDWL[79] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml80 VSS LDWL[80] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml81 VSS LDWL[81] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml82 VSS LDWL[82] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml83 VSS LDWL[83] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml84 VSS LDWL[84] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml85 VSS LDWL[85] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml86 VSS LDWL[86] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml87 VSS LDWL[87] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml88 VSS LDWL[88] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml89 VSS LDWL[89] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml90 VSS LDWL[90] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml91 VSS LDWL[91] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml92 VSS LDWL[92] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml93 VSS LDWL[93] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml94 VSS LDWL[94] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml95 VSS LDWL[95] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml96 VSS LDWL[96] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml97 VSS LDWL[97] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml98 VSS LDWL[98] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml99 VSS LDWL[99] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml100 VSS LDWL[100] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml101 VSS LDWL[101] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml102 VSS LDWL[102] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml103 VSS LDWL[103] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml104 VSS LDWL[104] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml105 VSS LDWL[105] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml106 VSS LDWL[106] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml107 VSS LDWL[107] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml108 VSS LDWL[108] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml109 VSS LDWL[109] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml110 VSS LDWL[110] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml111 VSS LDWL[111] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml112 VSS LDWL[112] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml113 VSS LDWL[113] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml114 VSS LDWL[114] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml115 VSS LDWL[115] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml116 VSS LDWL[116] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml117 VSS LDWL[117] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml118 VSS LDWL[118] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml119 VSS LDWL[119] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml120 VSS LDWL[120] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml121 VSS LDWL[121] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml122 VSS LDWL[122] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml123 VSS LDWL[123] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml124 VSS LDWL[124] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml125 VSS LDWL[125] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml126 VSS LDWL[126] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml127 VSS LDWL[127] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml128 VSS LDWL[128] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml129 VSS LDWL[129] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml130 VSS LDWL[130] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml131 VSS LDWL[131] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml132 VSS LDWL[132] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml133 VSS LDWL[133] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml134 VSS LDWL[134] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml135 VSS LDWL[135] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml136 VSS LDWL[136] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml137 VSS LDWL[137] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml138 VSS LDWL[138] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml139 VSS LDWL[139] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml140 VSS LDWL[140] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml141 VSS LDWL[141] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml142 VSS LDWL[142] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml143 VSS LDWL[143] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml144 VSS LDWL[144] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml145 VSS LDWL[145] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml146 VSS LDWL[146] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml147 VSS LDWL[147] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml148 VSS LDWL[148] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml149 VSS LDWL[149] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml150 VSS LDWL[150] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml151 VSS LDWL[151] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml152 VSS LDWL[152] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml153 VSS LDWL[153] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml154 VSS LDWL[154] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml155 VSS LDWL[155] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml156 VSS LDWL[156] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml157 VSS LDWL[157] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml158 VSS LDWL[158] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml159 VSS LDWL[159] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml160 VSS LDWL[160] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml161 VSS LDWL[161] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml162 VSS LDWL[162] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml163 VSS LDWL[163] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml164 VSS LDWL[164] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml165 VSS LDWL[165] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml166 VSS LDWL[166] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml167 VSS LDWL[167] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml168 VSS LDWL[168] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml169 VSS LDWL[169] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml170 VSS LDWL[170] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml171 VSS LDWL[171] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml172 VSS LDWL[172] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml173 VSS LDWL[173] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml174 VSS LDWL[174] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml175 VSS LDWL[175] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml176 VSS LDWL[176] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml177 VSS LDWL[177] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml178 VSS LDWL[178] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml179 VSS LDWL[179] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml180 VSS LDWL[180] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml181 VSS LDWL[181] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml182 VSS LDWL[182] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml183 VSS LDWL[183] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml184 VSS LDWL[184] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml185 VSS LDWL[185] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml186 VSS LDWL[186] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml187 VSS LDWL[187] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml188 VSS LDWL[188] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml189 VSS LDWL[189] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml190 VSS LDWL[190] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml191 VSS LDWL[191] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml192 VSS LDWL[192] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml193 VSS LDWL[193] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml194 VSS LDWL[194] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml195 VSS LDWL[195] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml196 VSS LDWL[196] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml197 VSS LDWL[197] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml198 VSS LDWL[198] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml199 VSS LDWL[199] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml200 VSS LDWL[200] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml201 VSS LDWL[201] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml202 VSS LDWL[202] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml203 VSS LDWL[203] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml204 VSS LDWL[204] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml205 VSS LDWL[205] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml206 VSS LDWL[206] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml207 VSS LDWL[207] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml208 VSS LDWL[208] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml209 VSS LDWL[209] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml210 VSS LDWL[210] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml211 VSS LDWL[211] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml212 VSS LDWL[212] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml213 VSS LDWL[213] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml214 VSS LDWL[214] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml215 VSS LDWL[215] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml216 VSS LDWL[216] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml217 VSS LDWL[217] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml218 VSS LDWL[218] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml219 VSS LDWL[219] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml220 VSS LDWL[220] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml221 VSS LDWL[221] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml222 VSS LDWL[222] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml223 VSS LDWL[223] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml224 VSS LDWL[224] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml225 VSS LDWL[225] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml226 VSS LDWL[226] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml227 VSS LDWL[227] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml228 VSS LDWL[228] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml229 VSS LDWL[229] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml230 VSS LDWL[230] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml231 VSS LDWL[231] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml232 VSS LDWL[232] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml233 VSS LDWL[233] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml234 VSS LDWL[234] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml235 VSS LDWL[235] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml236 VSS LDWL[236] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml237 VSS LDWL[237] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml238 VSS LDWL[238] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml239 VSS LDWL[239] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml240 VSS LDWL[240] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml241 VSS LDWL[241] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml242 VSS LDWL[242] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml243 VSS LDWL[243] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml244 VSS LDWL[244] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml245 VSS LDWL[245] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml246 VSS LDWL[246] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml247 VSS LDWL[247] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml248 VSS LDWL[248] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml249 VSS LDWL[249] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml250 VSS LDWL[250] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml251 VSS LDWL[251] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml252 VSS LDWL[252] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml253 VSS LDWL[253] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml254 VSS LDWL[254] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml255 VSS LDWL[255] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml256 VSS LDWL[256] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml257 VSS LDWL[257] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml258 VSS LDWL[258] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml259 VSS LDWL[259] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml260 VSS LDWL[260] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml261 VSS LDWL[261] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml262 VSS LDWL[262] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml263 VSS LDWL[263] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml264 VSS LDWL[264] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml265 VSS LDWL[265] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml266 VSS LDWL[266] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml267 VSS LDWL[267] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml268 VSS LDWL[268] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml269 VSS LDWL[269] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml270 VSS LDWL[270] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml271 VSS LDWL[271] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml272 VSS LDWL[272] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml273 VSS LDWL[273] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml274 VSS LDWL[274] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml275 VSS LDWL[275] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml276 VSS LDWL[276] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml277 VSS LDWL[277] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml278 VSS LDWL[278] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml279 VSS LDWL[279] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml280 VSS LDWL[280] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml281 VSS LDWL[281] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml282 VSS LDWL[282] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml283 VSS LDWL[283] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml284 VSS LDWL[284] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml285 VSS LDWL[285] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml286 VSS LDWL[286] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml287 VSS LDWL[287] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml288 VSS LDWL[288] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml289 VSS LDWL[289] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml290 VSS LDWL[290] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml291 VSS LDWL[291] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml292 VSS LDWL[292] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml293 VSS LDWL[293] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml294 VSS LDWL[294] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml295 VSS LDWL[295] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml296 VSS LDWL[296] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml297 VSS LDWL[297] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml298 VSS LDWL[298] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml299 VSS LDWL[299] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml300 VSS LDWL[300] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml301 VSS LDWL[301] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml302 VSS LDWL[302] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml303 VSS LDWL[303] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml304 VSS LDWL[304] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml305 VSS LDWL[305] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml306 VSS LDWL[306] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml307 VSS LDWL[307] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml308 VSS LDWL[308] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml309 VSS LDWL[309] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml310 VSS LDWL[310] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml311 VSS LDWL[311] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml312 VSS LDWL[312] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml313 VSS LDWL[313] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml314 VSS LDWL[314] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml315 VSS LDWL[315] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml316 VSS LDWL[316] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml317 VSS LDWL[317] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml318 VSS LDWL[318] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml319 VSS LDWL[319] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml320 VSS LDWL[320] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml321 VSS LDWL[321] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml322 VSS LDWL[322] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml323 VSS LDWL[323] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml324 VSS LDWL[324] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml325 VSS LDWL[325] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml326 VSS LDWL[326] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml327 VSS LDWL[327] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml328 VSS LDWL[328] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml329 VSS LDWL[329] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml330 VSS LDWL[330] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml331 VSS LDWL[331] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml332 VSS LDWL[332] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml333 VSS LDWL[333] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml334 VSS LDWL[334] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml335 VSS LDWL[335] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml336 VSS LDWL[336] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml337 VSS LDWL[337] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml338 VSS LDWL[338] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml339 VSS LDWL[339] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml340 VSS LDWL[340] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml341 VSS LDWL[341] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml342 VSS LDWL[342] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml343 VSS LDWL[343] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml344 VSS LDWL[344] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml345 VSS LDWL[345] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml346 VSS LDWL[346] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml347 VSS LDWL[347] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml348 VSS LDWL[348] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml349 VSS LDWL[349] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml350 VSS LDWL[350] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml351 VSS LDWL[351] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml352 VSS LDWL[352] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml353 VSS LDWL[353] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml354 VSS LDWL[354] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml355 VSS LDWL[355] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml356 VSS LDWL[356] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml357 VSS LDWL[357] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml358 VSS LDWL[358] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml359 VSS LDWL[359] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml360 VSS LDWL[360] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml361 VSS LDWL[361] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml362 VSS LDWL[362] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml363 VSS LDWL[363] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml364 VSS LDWL[364] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml365 VSS LDWL[365] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml366 VSS LDWL[366] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml367 VSS LDWL[367] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml368 VSS LDWL[368] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml369 VSS LDWL[369] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml370 VSS LDWL[370] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml371 VSS LDWL[371] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml372 VSS LDWL[372] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml373 VSS LDWL[373] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml374 VSS LDWL[374] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml375 VSS LDWL[375] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml376 VSS LDWL[376] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml377 VSS LDWL[377] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml378 VSS LDWL[378] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml379 VSS LDWL[379] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml380 VSS LDWL[380] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml381 VSS LDWL[381] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml382 VSS LDWL[382] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml383 VSS LDWL[383] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml384 VSS LDWL[384] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml385 VSS LDWL[385] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml386 VSS LDWL[386] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml387 VSS LDWL[387] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml388 VSS LDWL[388] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml389 VSS LDWL[389] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml390 VSS LDWL[390] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml391 VSS LDWL[391] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml392 VSS LDWL[392] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml393 VSS LDWL[393] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml394 VSS LDWL[394] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml395 VSS LDWL[395] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml396 VSS LDWL[396] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml397 VSS LDWL[397] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml398 VSS LDWL[398] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml399 VSS LDWL[399] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml400 VSS LDWL[400] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml401 VSS LDWL[401] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml402 VSS LDWL[402] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml403 VSS LDWL[403] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml404 VSS LDWL[404] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml405 VSS LDWL[405] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml406 VSS LDWL[406] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml407 VSS LDWL[407] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml408 VSS LDWL[408] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml409 VSS LDWL[409] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml410 VSS LDWL[410] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml411 VSS LDWL[411] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml412 VSS LDWL[412] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml413 VSS LDWL[413] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml414 VSS LDWL[414] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml415 VSS LDWL[415] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml416 VSS LDWL[416] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml417 VSS LDWL[417] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml418 VSS LDWL[418] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml419 VSS LDWL[419] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml420 VSS LDWL[420] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml421 VSS LDWL[421] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml422 VSS LDWL[422] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml423 VSS LDWL[423] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml424 VSS LDWL[424] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml425 VSS LDWL[425] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml426 VSS LDWL[426] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml427 VSS LDWL[427] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml428 VSS LDWL[428] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml429 VSS LDWL[429] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml430 VSS LDWL[430] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml431 VSS LDWL[431] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml432 VSS LDWL[432] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml433 VSS LDWL[433] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml434 VSS LDWL[434] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml435 VSS LDWL[435] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml436 VSS LDWL[436] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml437 VSS LDWL[437] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml438 VSS LDWL[438] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml439 VSS LDWL[439] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml440 VSS LDWL[440] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml441 VSS LDWL[441] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml442 VSS LDWL[442] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml443 VSS LDWL[443] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml444 VSS LDWL[444] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml445 VSS LDWL[445] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml446 VSS LDWL[446] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml447 VSS LDWL[447] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml448 VSS LDWL[448] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml449 VSS LDWL[449] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml450 VSS LDWL[450] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml451 VSS LDWL[451] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml452 VSS LDWL[452] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml453 VSS LDWL[453] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml454 VSS LDWL[454] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml455 VSS LDWL[455] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml456 VSS LDWL[456] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml457 VSS LDWL[457] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml458 VSS LDWL[458] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml459 VSS LDWL[459] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml460 VSS LDWL[460] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml461 VSS LDWL[461] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml462 VSS LDWL[462] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml463 VSS LDWL[463] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml464 VSS LDWL[464] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml465 VSS LDWL[465] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml466 VSS LDWL[466] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml467 VSS LDWL[467] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml468 VSS LDWL[468] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml469 VSS LDWL[469] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml470 VSS LDWL[470] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml471 VSS LDWL[471] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml472 VSS LDWL[472] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml473 VSS LDWL[473] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml474 VSS LDWL[474] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml475 VSS LDWL[475] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml476 VSS LDWL[476] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml477 VSS LDWL[477] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml478 VSS LDWL[478] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml479 VSS LDWL[479] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml480 VSS LDWL[480] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml481 VSS LDWL[481] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml482 VSS LDWL[482] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml483 VSS LDWL[483] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml484 VSS LDWL[484] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml485 VSS LDWL[485] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml486 VSS LDWL[486] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml487 VSS LDWL[487] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml488 VSS LDWL[488] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml489 VSS LDWL[489] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml490 VSS LDWL[490] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml491 VSS LDWL[491] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml492 VSS LDWL[492] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml493 VSS LDWL[493] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml494 VSS LDWL[494] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml495 VSS LDWL[495] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml496 VSS LDWL[496] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml497 VSS LDWL[497] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml498 VSS LDWL[498] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml499 VSS LDWL[499] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml500 VSS LDWL[500] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml501 VSS LDWL[501] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml502 VSS LDWL[502] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml503 VSS LDWL[503] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml504 VSS LDWL[504] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml505 VSS LDWL[505] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml506 VSS LDWL[506] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml507 VSS LDWL[507] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml508 VSS LDWL[508] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml509 VSS LDWL[509] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml510 VSS LDWL[510] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1
ml511 VSS LDWL[511] 0 0 cmosn AD=17.6e-12 AS=17.6e-12 L=2.4e-06 PD=16.8e-06 PS=16.8e-06 W=4e-06 m=1

* /last bitline



**** end user architecture code
**.ends
.end
