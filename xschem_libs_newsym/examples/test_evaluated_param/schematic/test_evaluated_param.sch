** sch_path: xschem_libs_newsym/examples/test_evaluated_param/schematic/test_evaluated_param.sch
**.subckt test_evaluated_param Z A
*.iopin Z
*.iopin A
R1 Z A 2500 * @DEL m=1
C1 Z GND 100f * @DEL m=1
**** begin user architecture code


.param DEL=@DEL
** do something with DEL


**** end user architecture code
**.ends
.GLOBAL GND
.end
