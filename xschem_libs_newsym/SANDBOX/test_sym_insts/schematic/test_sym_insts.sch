v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 30 60 80 60 {lab=#net1}
N 30 60 30 80 {lab=#net1}
N 30 80 80 80 {lab=#net1}
C {SANDBOX/test_sym} 230 70 0 0 {name=x1}
